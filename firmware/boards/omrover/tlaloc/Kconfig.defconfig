## firmware/boards/omrover/tlaloc/board.yml
```yaml
board:
  name: tlaloc
  full_name: Omrover Tlaloc (FRDM-A-S32K344)
  socs:
    - name: s32k344
```
